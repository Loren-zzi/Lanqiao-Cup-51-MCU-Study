# Keil uVision project Object.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Object +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c CBuzz.c CBuzz.h CLED.h CLED.c Delay.c Delay.h STC15F2K60S2.h AT24C02.c AT24C02.h I2C.c I2C.h Nixie.c Nixie.h Timer0.c Timer0.h DS1302.c DS1302.h
