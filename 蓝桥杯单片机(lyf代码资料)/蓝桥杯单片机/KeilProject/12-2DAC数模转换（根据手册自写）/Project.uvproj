# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c CBuzz.c CBuzz.h CLED.c CLED.h PCF8591.c I2C.c I2C.h Timer0.c Timer0.h Nixie.c Nixie.h PCF8591.h
