# Keil uVision project LED_1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: LED_1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: ex1.c CBuzz.c CBuzz.h Delay.c Delay.h Key.c Key.h Nixie.c Nixie.h CLED.c CLED.h
