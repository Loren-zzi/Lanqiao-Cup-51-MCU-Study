# Keil uVision project Project.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: Project +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c CBuzz.c CBuzz.h CLED.c CLED.h Timer0.c Timer0.h Nixie.c Nixie.h DS18B20.c DS18B20.h OneWire.c OneWire.h Delay.c Delay.h I2C.c I2C.h AT24C02.c AT24C02.h Matrixkey.c Matrixkey.h
