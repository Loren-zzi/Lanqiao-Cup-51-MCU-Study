# Keil uVision project 040521.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 040521 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LYF.c onewire.c onewire.h STC15F2K60S2.h
